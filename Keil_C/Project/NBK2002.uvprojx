# Keil uVision project NBK2002.uvprojx, settings and files
target <NBK2002> (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: NBK2002 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: SC32f12xx
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS;..\FreeRTOS\portable\RVDS\ARM_CM0;..\FreeRTOS\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group FreeRTOS
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Apps
    ../Apps/: FreeRTOS_Hook.c UART_Circular_Buffer.c print.c
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_dma.c sc32f1xxx_uart.c sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c
  group Startup
    ./: startup_sc32f12xx.s
